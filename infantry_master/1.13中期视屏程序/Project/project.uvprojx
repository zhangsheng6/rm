# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,__FPU_PRESENT=1,ARM_MATH_CM4,__CC_ARM,USE_DMP,MPL_LOG_NDEBUG=1,EMPL,MPU9250,EMPL_TARGET_STM32F4
  c include: ..\Project;..\Stdlib\inc;..\SystemInitFile;..\Stdlib\src;..\Stdlib\Core;..\Driver_Control;..\Driver_Init;..\Driver_Task;..\Remote;..\Init_ZS;..\APP_ZS;..\Math_Control_ZS;..\Control_ZS;..\IMU_DMP;..\IMU_DMP\MPL;..\IMU_DMP\MPL\driver\eMPL;..\IMU_DMP\MPL\driver\include;..\IMU_DMP\MPL\driver\stm32L;..\IMU_DMP\MPL\eMPL-hal;..\IMU_DMP\MPL\mllite;..\IMU_DMP\MPL\mpl;..\MPU9250;..\CAN
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group main
    ./: init.c main.c IO_Note.h delay.c
    ../SystemInitFile/: arm_cortexM4lf_math.lib stm32f4xx.h stm32f4xx_conf.h
  group INIT_ZS
    ../Init_ZS/: NVIC_ZS.c PWM_Init_ZS.c PWM_Init_ZS.h
    ./: NVIC_ZS.h GPIO_ZS.c GPIO_ZS.h Init_All.c Init_All.h init.h
  group APP_ZS
    ../APP_ZS/: Thread_ZS.c Thread_ZS.h
    ../Driver_Task/: Control_Task.c
  group CAN_ZS
    ../Driver_Init/: Can1_Init.c
    ../Driver_Task/: Can_Task.c
    ../Driver_Control/: CanBus.c
    ../CAN/: CAN2_Init.c CAN2_Init.h
  group USART_ZS
    ../Remote/: UsartRevicer.c
    ../Init_ZS/: UART_Send_ZS.c UART_Send_ZS.h USART_ZS.c USART_ZS.h USART_Wave_ShanWAI.c USART_Wave_ShanWAI.h usart_pc.c usart_pc.h
  group Remote
    ../Remote/: RemoteTask.c
  group MPU9250
    ../MPU9250/: MPU9250_Read_ZS.c MPU9250_Read_ZS.h
  group Control_ZS
    ../Control_ZS/: Encoder_ZS.c Encoder_ZS.h Chassis_Control.c Chassis_Control.h Poke_Control_ZS.c Poke_Control_ZS.h GM_Control_ZS.c GM_Control_ZS.h PY_Control_ZS.c PY_Control_ZS.h friction_servo_control.c friction_servo_control.h
  group Math_Control_ZS
    ./: PID_Control_ZS.c PID_Control_ZS.h
    ../Math_Control_ZS/: Ramp_Control_ZS.c Ramp_Control_ZS.h mymath.c mymath.h
  group Libray
    ../Stdlib/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_syscfg.c
  group IMU_DMPMPL
    ../IMU_DMP/: MPU6050_i2c.c mpu6050_interrupt.c mpu9250.c
    ../IMU_DMP/MPL/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../IMU_DMP/MPL/driver/stm32L/: log_stm32.c
    ../IMU_DMP/MPL/eMPL-hal/: eMPL_outputs.c
    ../IMU_DMP/MPL/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
    ../IMU_DMP/MPL/mpl/: libmpllib.lib
  group Comment
    ../Math_Control_ZS/: PID_Comment.h Balance_Coment.h
    ../Comment/: PY_Data_Comment.h cascade_PID.h 理解.txt 底盘中心板.txt ID.txt 引脚.txt Engineer_Assistant.txt PY调节参数.txt PID思路.txt 底盘调试参数.txt
    ./: PID调节参数2.txt 电流环.txt
software components: CMSIS:CORE 5.1.1, CMSIS:RTOS:Keil RTX5 5.3.0, CMSIS:RTOS2:Keil RTX5 5.3.0, Device:Startup 2.5.0
