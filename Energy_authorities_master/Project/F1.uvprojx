# Keil uVision project F1.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103T8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: F1
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Main;..\Driver_Init;..\Periph_Init;..\Task;..\Periph_Handle;..\Usart;..\Math;..\Deal
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Main
    ../Main/: main.c init.c init.h sys.h
  group Driver_Init
    ../Driver_Init/: tim.c tim.h nvic.c nvic.h
    ../Main/: delay.c delay.h
  group Periph_Init
    ../Driver_Init/: can.c can.h
    ../Usart/: usart.c usart.h
    ../Periph_Init/: led.c led.h
  group Periph
    ../Periph_Handle/: encoder.c encoder.h
  group Deal
    ../Deal/: can_tr.c can_tr.h
  group Task
    ../Task/: energy_authorities_task.c energy_authorities_task.h
  group Note
    ../Note/: 便捷.txt IO口分配.txt
  group Usart
    ../Usart/: UART_Send_ZS.c USART_Wave_ShanWAI.c UART_Send_ZS.h USART_Wave_ShanWAI.h
  group Math
    ../Math/: pid.c pid.h
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:BKP 3.5.0, Device:StdPeriph Drivers:CAN 3.5.0, Device:StdPeriph Drivers:CEC 3.5.0, Device:StdPeriph Drivers:CRC 3.5.0, Device:StdPeriph Drivers:DAC 3.5.0, Device:StdPeriph Drivers:DBGMCU 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:FSMC 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:IWDG 3.5.0, Device:StdPeriph Drivers:PWR 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:RTC 3.5.0, Device:StdPeriph Drivers:SDIO 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0, Device:StdPeriph Drivers:WWDG 3.5.0
